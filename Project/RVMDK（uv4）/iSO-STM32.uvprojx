# Keil uVision project iSO-STM32.uvprojx, settings and files
target STM32_DEMO (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER ,PLATFORM=SX12xxEiger
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\SysTick;..\..\User\SX1278;..\..\User\SX1278\radio;..\..\User\SX1278\platform\bleeper;..\..\User\SX1278\platform\sx1200dvk;..\..\User\SX1278\platform\sx1243ska;..\..\User\SX1278\platform\sx12xxEiger;..\..\User\SX1278\platform;..\..\Libraries\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h sys_config.c 18b20.c OLED_I2C.c codetab.h uartPort.c bsp_spi_flash.c flashmgr.c debug.c menu.c device.c info_source.h
    ../../User/usart/: bsp_usart.c
    ../../User/SysTick/: bsp_timer.c
  group radio
    ../../User/SX1278/radio/: radio.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group sx12xxEiger
    ../../User/SX1278/platform/sx12xxEiger/: fifo.c spi.c sx12xxEiger.c sx1276-Hal.c
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../../Doc/: readme.txt
software components: CMSIS:CORE 4.1.0
